## linux-3.10.60/drivers/ldr/Kconfig
```kconfig
menu "the linux device driver samples"

config LDR_SCULL
	tristate "scull driver samples"

endmenu
```
